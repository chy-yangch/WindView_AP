# Keil uVision project WindView.uvprojx, settings and files
target WindView (6240000::V6.24::ARMCLANG)
  device: M251SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: 1491-WindView-001
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\M251\Include;.\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
    ./Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ./Library/StdDriver/src/: clk.c fmc.c retarget.c timer.c pdma.c uart.c eadc.c gpio.c i2c.c sys.c rtc.c wdt.c
  group User
    ./SRC/: main.c
